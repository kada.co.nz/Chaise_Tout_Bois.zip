Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:03:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:03:27 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{87454719-1AAF-4EF2-9952-5CDA49712C1D}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:03:24 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:03:25 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:03:25 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Chaise Tout Bois - Dark Oak, Furniture_Chairs_Vitra_Chaise_Tout_Bois:Chaise Tout Bois - Dark Oak:319247
In: Level 1
Type - Material: dark oak with protective varnish 04, Glide black
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Chaise_Tout_Bois; ConvergoRefNr: 0089-2006-0002-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Chaise Tout Bois is the only chair by the French 'constructeur' and designer Jean Prouvé that is made entirely out of wood.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Collection: Chaise Tout Bois; Cost: 0; Description: Chaise Tout Bois is the only chair by the French 'constructeur' and designer Jean Prouvé that is made entirely out of wood.; Designer: Jean Prouvé, 1941; Manufacturer: Vitra; Model: Chaise Tout Bois; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-cn/_storage/asset/3465601/storage/master/download/Factsheet%20Standard%20Chaise%20Tout%20Bois-EN.pdf; Type Name: Chaise Tout Bois - Dark Oak; URL: https://www.vitra.com/en-cn/living/product/details/chaise-tout-bois
Type - Materials and Finishes(Type) - ChairMainMaterial: dark oak with protective varnish 04; ChairSecondaryMaterial: Glide black
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Chaise_Tout_Bois; Features: n/a; Finish: Seat and backrest: moulded plywood veneer in natural or dark-stained oak, protective natural lacquer finish.Base: non-stackable solid wood base; same type of wood as backrest and seat in natural or dark-stained oak, protective natural lacquer finish.Origin of wood: solid oak (Quercus robur) from Croatia, veneer wood from Germany and the USA.; Grade: n/a; Material: Wood; ModelNumber: n/a; ModelReference: 09189102; Name: Vitra_Chaise_Tout_Bois; ReplacementCost: n/a; Shape: Sculptured; Size: 460x490x805 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 09189102; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.99015 m2; Volume: 0.181447 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Chaise_Tout_Bois: Chaise Tout Bois - Dark Oak; Family and Type: Furniture_Chairs_Vitra_Chaise_Tout_Bois: Chaise Tout Bois - Dark Oak; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Chaise_Tout_Bois: Chaise Tout Bois - Dark Oak; Type Id: Furniture_Chairs_Vitra_Chaise_Tout_Bois: Chaise Tout Bois - Dark Oak; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
